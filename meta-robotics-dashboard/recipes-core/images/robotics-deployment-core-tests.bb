# robotics-dashboard-core-tests.bb

require recipes-core/images/robotics-dashboard-core.bb
inherit testimage
